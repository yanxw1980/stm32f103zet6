# Keil uVision project LoaderPrj.uvprojx, settings and files
target LoaderProj (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoaderPrj +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\BSP;..\BSP\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\UCOS\uCOS-III\Source;..\UCOS\uC-LIB;..\UCOS\uC-CPU;..\USR;..\UCOS\uCOS-III\Ports;..\UCOS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/: BSP.c bsp_int.c bsp_os.c bsp_periph.c bsp_ser.c os_app_hooks.c startup_stm32f10x_hd.s
    ../BSP/CoreSupport/: core_cm3.c
    ../UCOS/uC-CPU/: cpu_a.asm
  group UCOS
    ../UCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../UCOS/uC-CPU/: cpu_c.c cpu_core.c
    ../UCOS/uCOS-III/Ports/: os_cpu_a.asm os_cpu_c.c
  group USR
    ../USR/: main.c stm32f10x_it.c CrcModbus.c Adc7689.c BoardIoDef.c MotorBsp.C MotorDrv.C RotValveDef.c HexProtocol.c ModbusProl.c SpiDrv.c SpiFlash.c XLP6000.c
